Commit message: green ball

File: urdf/ball.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link ball_link: geometry visual sphere radius=0.05
